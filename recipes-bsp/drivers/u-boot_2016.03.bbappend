UBOOT_MACHINE_odroidxu3 = "odroidx-u3_defconfig"
RDEPENDS_${PN} = "secure-odroidxu3"
